# Keil uVision project elec_scale.uvprojx, settings and files
target elec_scale (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SC32F12TS8 SinOneMicroelectronics
  pack: SinOne.SinOneM_DFP.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: elec_scale +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: SC32f12xx
  c include: ..\FWLib\SC32F1XXX_Lib\inc;..\User\HeadFiles;..\User;..\Drivers;..\Apps;..\CMSIS;..\HardDrive;..\Application
  memory RVCT4: ROM 0x08000000 size 0x00040000
  memory RVCT9: ROM 0x20000000 size 0x00004000
  group User
    ../User/: main.c system_sc32f1xxx.c SC_it.c SC_Init.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c
  group Application
    ../Application/: key_handler.c app_init.c system_timer.c scale_manager.c
  group HardDrive
    ../HardDrive/: weight_sensor.c key.c buzzer.c
  group FWLib
    ../FWLib/SC32F1XXX_Lib/src/: sc32f1xxx_option.c sc32f1xxx_rcc.c sc32f1xxx_gpio.c sc32f1xxx_wdt.c sc32f1xxx_uart.c sc32f1xxx_twi.c sc32f1xxx_tim.c sc32f1xxx_spi.c sc32f1xxx_pwr.c sc32f1xxx_pwm.c sc32f1xxx_op.c sc32f1xxx_ledpwm.c sc32f1xxx_led.c sc32f1xxx_lcd.c sc32f1xxx_int.c sc32f1xxx_iap.c sc32f1xxx_dma.c sc32f1xxx_crc.c sc32f1xxx_cmp.c sc32f1xxx_btm.c sc32f1xxx_adc.c
  group Startup
    ./: startup_sc32f12xx.s
